PROGRAM MAIN
VAR
	myStatusLamp : T_SmartLight;
	myErrorLamp : T_SmartLight;
END_VAR

myStatusLamp.SwitchAllLampsOff();

END_PROGRAM
